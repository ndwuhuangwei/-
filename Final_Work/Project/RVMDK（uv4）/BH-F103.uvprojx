# Keil uVision project BH-F103.uvprojx, settings and files
target Final_Work (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FinalWork +hex
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\led;..\..\User\BasicTim;..\..\User\usart;..\..\User\sys;..\..\User\delay;..\..\User\beep;..\..\User\key;..\..\User\SPI;..\..\User\TFTLCD;..\..\User\DHT11;..\..\User\VL53L0X\core\inc;..\..\User\VL53L0X\demo;..\..\User\VL53L0X\platform\inc;..\..\User\24CXX;..\..\User\IIC;..\..\User\ESP8266;..\..\User\Common;..\..\User\HCSR04
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group DOC
    ../../Doc/: readme.txt Function Description.txt ESP8266.txt
  group SYS
    ../../User/BasicTim/: bsp_BasicTim.c
    ../../User/beep/: beep.c
    ../../User/key/: bsp_key.c
    ../../User/Led/: bsp_led.c
    ../../User/usart/: bsp_usart.c
    ../../User/delay/: delay.c
    ../../User/sys/: sys.c
  group HardWare
    ../../User/SPI/: spi.c
    ../../User/TFTLCD/: tftlcd.c
    ../../User/DHT11/: bsp_dht11.c
    ../../User/HCSR04/: hcsr04.c
  group VL053LX
    ../../User/VL53L0X/core/src/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c
    ../../User/VL53L0X/demo/: vl53l0x.c vl53l0x_gen.c
    ../../User/VL53L0X/platform/src/: vl53l0x_i2c.c vl53l0x_platform.c
  group ATK-ESP8266
    ../../User/Common/: Common.c
    ../../User/ESP8266/: bsp_esp8266.c
